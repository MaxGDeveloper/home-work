// ПИД-регулятор по заданной относительной скорости
// Регулятор без обратной связи по передаточному коэффициенту (при Кп = Ки = Кд = 0)
// Помеха по управлению
// Задание линейно растущего закона управления
// Задание частотного закона управления
// Любая комбинация параметров постоянного, линейного и частотного законов
// Ключи ввода в монитор порта:
//    set<целое число 0..4000> - задание скорости вращения, об/мин
//   ramp<целое число -1000..1000> - коэффициент линейного роста уставки, об/мин/с
//   ampl<целое число 0..1000> - амплитуда частотной уставки, об/мин
//   freq<вещественное число 0.0..20.0> - частота частотной уставки, рад/с
//     kp<вещественное число 0.0..10.0> - коэффициент П регулятора
//     ki<вещественное число 0.0..10.0> - коэффициент И регулятора
//     kd<вещественное число 0.0..10.0> - коэффициент И регулятора
//    vup<целое число -20..20> - помеха по управлению
//    out<целое число 10..2000> - задание периода вывода в монитор порта, мс
//    out - остановить/запустить вывод данных
//    imp<целое число 1..100 > - задание количества оборотов в расчёте скорости

// Подключение вентилятора:
#define pin_PWM 3 // Шим вентилятора
#define pin_TAH 2 // Тахометр вентилятора - прерывание

//-------------------- Переменные --------------------//

// Параметры вентилятора:
uint8_t pwm_min = 30, // Диапазон ШИМ 
        pwm_max = 250; // для относительного управления
uint16_t obm_min = 275, // Диапазон скоростей 
         obm_max = 2280; // для относительного управления
float K = 9.89; // Передаточный коэффициент

// Настройки регулятора:
float Kp = 5,    // Коэффициенты регулятора
      Ki = 0.0,
      Kd = 0.0;

// Переменные управления:
int16_t pwm; // Значение ШИМ - управляющий сигнал
float Set, set_M; // Задающий сигнал (уставка), об/мин
float upr; // Управляющий сигнал регулятора
int8_t Vup; // Помеха по управлению
int16_t ramp; // Коэффициент линейного роста уставки
int16_t ampl; // Амплитуда частотной уставки
float freq; // Частота частотной уставки
float tim; // Текущее время уставки для частотного закона
float del, del_, // Ошибка управления
      intgr, // Интеграл ошибки
      diffr; // Скорость ошибки
uint16_t T_out = 50; // Период вывода в монитор порта, мс
bool outs = true; // Запуск/останов вывода

// Переменные тахометра:
bool impb; // Переключение индикатора
float obm; // Обороты в минуту
uint8_t n_imp = 1; // Количество оборотов - двойных импульсов в рассчёте времени
volatile uint32_t tim_imp; // Время импульсов тахометра
volatile bool flag_taho = false; // Флаг готовности данных тахометра

//-------------------- Функции --------------------//

// Функция по прерыванию тахометра:
void taho () {
  static uint32_t tmr_imp; // Таймер импульсов
  static uint8_t imp; // Счётчик импульсов
  imp++;
  if (imp >= n_imp * 2) { // Прошло n импульсов
    tim_imp = micros() - tmr_imp; // Время оборотов
    tmr_imp = micros(); // Сброс таймера
    imp = 0; // Сброс счётчика
    flag_taho = true; // Флаг готовности
  }
}

//Функция управления:
void uprput() {
  if (flag_taho) { // По флагу готовности тахометра
    // Формирование закона управления:
    if (ampl == 0 || freq == 0) {
      Set = Set + tim_imp / 1000000.0 * ramp; // Линейный рост уставки
      if (set_M != 0) {
        set_M = 0; tim = 0;
      }
    }
    else {
      if (set_M == 0) set_M = Set; // Средняя нейтральная линия частотной уставки
      else set_M = set_M + tim_imp / 1000000.0 * ramp;
      tim = tim + tim_imp / 1000000.0; // Текущее время уставки
      Set = set_M + ampl * sin(freq * tim); // Частотная уставка
    }
    if (Set <= 0) ramp = abs(ramp); // Ограничитель роста уставки вниз
    if (Set >= obm_max - obm_min) ramp = -abs(ramp); // Ограничитель роста уставки вверх
    Set = constrain(Set, 0, obm_max - obm_min); // Ограничитель уставки

    // Вычисление управляющего воздействия:
    obm = filtr(60000000.0 / tim_imp * n_imp) - obm_min; // Обороты в минуту ОТНОСИТЕЛЬНЫЕ
    del_ = del; // Предыдущая ошибка
    del = Set - obm; // Ошибка управления
    if (Set != 0 && Ki != 0)
      intgr = intgr + del * tim_imp / 1000000.0; // Интеграл ошибки
    else intgr = 0;
    diffr = (del - del_) / tim_imp * 1000000.0; // Скорость ошибки
    if (Kp != 0 || Ki != 0 || Kd != 0)
      upr = Kp * del + Ki * intgr + Kd * diffr ; // Регулятор
    else upr = Set / K; // Разомкнутое управление

    upr = constrain(upr, 0, pwm_max - pwm_min); // Управляющий сигнал регулятора
    pwm = upr + Vup; // Управляющее воздействие с учётом помехи управления
    analogWrite(pin_PWM, constrain(pwm + pwm_min, 0, 255)); // Управление вентилятором

    flag_taho = false; // Сброс флага готовности данных тахометра
    impb = !impb; // Переключение индикатора
    digitalWrite(13, impb); // Индикатор на плате
  }
}

// Функция вывода:
void output() {
  static uint32_t tmr_out;
  if (outs && millis() - tmr_out > T_out) { // Таймер
    tmr_out = millis();
    Serial.print(obm);
    Serial.print(' ');
    Serial.print(Set);
    Serial.print(' ');
    Serial.print(upr);
    Serial.println();
  }
}

// Получение данных из терминала:
void terminal() {
  static char cmd[20]; // Массив символов из порта
  static int index = 0; // Счётчик символов
  if (Serial.available()) { // Что-то пришло
    char ch = (char)Serial.read(); // Чтение символа из порта
    if (ch == '\r' || ch == '\n') { // Если конец строки
      cmd[index] = 0;
      index = 0;
      // Ключи полученной строки:
      if (strncmp(cmd, "ramp", 4) == 0) {
        ramp = constrain(atoi(cmd + 4), -1000, 1000); // Коэффициент линейного роста уставки
        return;
      }
      if (strncmp(cmd, "ampl", 4) == 0) {
        ampl = constrain(atoi(cmd + 4), 0, 1000); // Коэффициент линейного роста уставки
        return;
      }
      if (strncmp(cmd, "freq", 4) == 0) {
        freq = constrain(atoi(cmd + 4), 0, 20); // Коэффициент линейного роста уставки
        return;
      }
      if (strncmp(cmd, "kp", 2) == 0) {
        Kp = constrain(atof(cmd + 2), 0, 10); // Коэффициент П регулятора
        return;
      }
      if (strncmp(cmd, "ki", 2) == 0) {
        Ki = constrain(atof(cmd + 2), 0, 10); // Коэффициент И регулятора
        return;
      }
      if (strncmp(cmd, "kd", 2) == 0) {
        Kd = constrain(atof(cmd + 2), 0, 10); // Коэффициент Д регулятора
        return;
      }
      if (strncmp(cmd, "set", 3) == 0) {
        if (ampl == 0 || freq == 0)
          Set = constrain(atoi(cmd + 3), 0, obm_max - obm_min); // Скорость заданная
        else
          set_M = constrain(atoi(cmd + 3), 0, obm_max - obm_min); // Средняя нейтральная линия частотной уставки
        return;
      }
      if (strncmp(cmd, "vup", 3) == 0) {
        Vup = constrain(atoi(cmd + 3), -20, 20); // Помеха по управлению
        return;
      }
      if (strncmp(cmd, "imp", 3) == 0) {
        n_imp = constrain(atoi(cmd + 3), 1, 100); // Количество импульсов в измерении
        return;
      }
      if (strncmp(cmd, "out", 3) == 0) {        
        if (atoi(cmd + 3) != 0)
          T_out = constrain(atoi(cmd + 3), 10, 2000); // Период вывода
        else outs = !outs;
        return;
      }
    }
    else { // Принимаем следующий символ из порта
      cmd[index++] = ch;
    }
  }
}

// Медианный фильтр случайных выбросов:
float filtr(float newVal) {
  static float buf[3]; // Буфер из трёх значений
  static byte count = 0; // Счётчик
  buf[count] = newVal;
  if (++count >= 3) count = 0; // Выбор среднего значения из трёх - медианы:
  return (max(buf[0], buf[1]) == max(buf[1], buf[2])) ? max(buf[0], buf[2]) : max(buf[1], min(buf[0], buf[2]));
}

//-------------------- Инициализация МК --------------------//

void setup() {
  Serial.begin(9600); // Запуск монитора порта
  pinMode(pin_PWM, OUTPUT); // ШИМ
  pinMode(pin_TAH, INPUT_PULLUP); // Тахометр
  pinMode(13, OUTPUT); // Индикатор на плате
  attachInterrupt(0, taho, RISING); // Прерывание 0 на D2 (1 на D3)
  analogWrite(pin_PWM, pwm_min); // Запуск вентилятора
  delay(2000);
}

//-------------------- Главный цикл МК --------------------//

void loop() {
  terminal();
  output();
  uprput();
}
